<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Template_IAR_Project\TemplateProject.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab 1\TemplateProject.ewp</path>
    </project>
    <batchBuild />
</workspace>
